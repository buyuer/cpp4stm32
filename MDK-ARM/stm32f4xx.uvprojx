# Keil uVision project stm32f4xx.uvprojx, settings and files
target stm32f4xx (6120000::V6.12::.\ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4xx +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32F407xx
  c include: ..\Library\Cube\CMSIS\Core;..\Library\Cube\CMSIS\ST;..\Library\Cube\HAL\Inc;..\Library\Cube\LL\Inc;..\Library\UPRE;..\CubeMX\Core\Inc;..\Library\freeRTOS\include;..\Library\freeRTOS\portable\GCC\ARM_CM4F;..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/: user_task.cpp user_interrupt.cpp user_start.cpp FreeRTOSConfig.h user_global_var.cpp user_global_var.hpp
  group UPRE
    ../Library/UPRE/: Base.cpp Base.hpp cpp4stm32.hpp SerialPort.cpp SerialPort.hpp Robot.cpp Robot.hpp Handle.cpp Handle.hpp Motor.cpp Motor.hpp Sensor.cpp Sensor.hpp
  group CUBEMX
    ../CubeMX/Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_timebase_tim.c
    ../CubeMX/Core/Inc/: main.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group CMSIS
    ../Library/Cube/CMSIS/Core/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
    ../Library/Cube/CMSIS/Startup/arm/: startup_stm32f407xx.s
  group FreeRTOS-CORE
    ../Library/freeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Library/freeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS-PORTABLE
    ../Library/freeRTOS/portable/GCC/ARM_CM4F/: port.c portmacro.h
    ../Library/freeRTOS/portable/MemMang/: heap_4.c
  group LIB
    ../MDK-ARM-LIB/Objects/: hal_ll_lib.lib
